FILES:${PN} += "${libdir}/rpicam_app.so.*"
INSANE_SKIP:${PN} += "32bit-time"
